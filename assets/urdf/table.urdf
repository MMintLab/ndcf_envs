Commit message: heterogenous object pushing

File: assets/urdf/table.urdf (robot description, URDF)
Before this commit: robot table, 2 links, 1 joints
Links:
- link table: geometry collision box size=1.0 1.0 0.01; visual box size=1.0 1.0 0.01
